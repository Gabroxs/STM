<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\generator_lez_13.ewp</path>
    </project>
    <batchBuild />
</workspace>
