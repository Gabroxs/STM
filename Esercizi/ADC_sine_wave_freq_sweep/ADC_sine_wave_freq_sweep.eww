<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_sine_wave_freq_sweep.ewp</path>
    </project>
    <batchBuild />
</workspace>
