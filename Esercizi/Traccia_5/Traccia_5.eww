<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\adc_lez_8\adc_lez_8.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Traccia_5.ewp</path>
    </project>
    <batchBuild />
</workspace>
